# Repository kathirvel13/drone-basics

File README.md:

# drone-basics
Documentation of my journey of building a drone.

List of all [datasheets](https://drive.google.com/drive/folders/1iUG29b2cMh-5nq3NcYLO3N7c_ATjr1fG) of components

## KiCad design DIY Drone - Project Dronachariya/All Important/LiteWing/LiteWingV2.5C/LiteWingV2.5C.kicad_pcb

Parts:
C1, C4, C5, C12: 10uF; C_0603_1608Metric; MFR.Part # CL10A106KP8NNNC; LCSC Part # C19702
C2: 470pF; C_0603_1608Metric; MFR.Part # 0603B471K500NT; LCSC Part # C1620
C3: 2.2uF; C_0805_2012Metric; MFR.Part # TCC0805X7R225M250FT; LCSC Part # C5448893
C6, C7, C8, C10, C13, C14: 100nF; C_0603_1608Metric; MFR.Part # CC0603KRX7R9BB104; LCSC Part # C14663
C9: 2.2nf; C_0603_1608Metric; MFR.Part # 0603B222K500NT; LCSC Part # C1604
C11: 10nf; C_0603_1608Metric; MFR.Part # 0603B103K500NT; LCSC Part # C57112
C15, C16, C17, C18: 1uF; C_0603_1608Metric; MFR.Part # CL10A105KB8NNNC; LCSC Part # C15849
D1: SS34; D_SMA; MFR.Part # SS34; LCSC Part # C8678
D2, D3, D4, D5: 1N4148W; D_SOD-123F; MFR.Part # 1N4148W; LCSC Part # C81598
IC1: TP4056; SOIC127P600X175-9N; MFR.Part # TP4056; LCSC Part # C20199357
J1: USB_C_Receptacle_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12; MFR.Part # USB-TYPE-C-018; LCSC Part # C2927038
J2: JST XH 2P 2.50mm SMD Hoz; CONN-TH_2P-P2.50_XH-2AW; MFR.Part # XH-2AW; LCSC Part # C33132
J3, J4, J5, J6: Conn_01x06; PinHeader_1x06_P2.54mm_Vertical
J7, J8, J9, J10: Conn_01x02_Female; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
J11: Conn_01x09; PMW3901
J12: Conn_01x06; VL53L1X_BREAKOUT
J13: Conn_01x07; MS5611_Module
J14: Conn_01x02; CONN-TH_1.25T-2A_1.25T-2A; MFR.Part # 1.25-2A; LCSC Part # C722594
LED1, LED2, LED5: LED_Red; LED_0603_1608Metric; MFR.Part # KT-0603R; LCSC Part # C2286
LED3, LED6: LED_Blue; LED_0603_1608Metric; MFR.Part # KT-0603B; LCSC Part # C2288
LED4: LED_Green; LED_0603_1608Metric; MFR.Part # LTST-C193TGKT-5A; LCSC Part # C12065
R1, R2: 5.1K; R_0603_1608Metric; MFR.Part # 0603WAF5101T5E; LCSC Part # C23186
R3, R8, R26, R27: 100K; R_0603_1608Metric; MFR.Part # 0603WAF1003T5E; LCSC Part # C25803
R4: 470R; R_0603_1608Metric; MFR.Part # 0603WAF4700T5E; LCSC Part # C23179
R5: 1.2K; R_0603_1608Metric; MFR.Part # 0603WAF1201T5E; LCSC Part # C22765
R6, R7, R9, R10, R11, R12, R13: 1K; R_0603_1608Metric; MFR.Part # 0603WAF1001T5E; LCSC Part # C21190
R14, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25: 10k; R_0603_1608Metric; MFR.Part # 0603WAF1002T5E; LCSC Part # C25804
R15: 4.7k; R_0603_1608Metric; MFR.Part # 0603WAF4701T5E; LCSC Part # C23162
R28, R29, R30: 0R; R_0603_1608Metric; MFR.Part # 0603WAF0000T5E; LCSC Part # C21189
SW1: MST22D18G2_125; SW-SMD_MST22D18G2; MFR.Part # MST22D18G2 125; LCSC Part # C2906280
SW2, SW3: Tactile Switch 3x4x2; Tactile 3x4x2mm TS-A010; MFR.Part # TS-KG88C-ART25F; LCSC Part # C2874433
T1, T2, T3, T4: IRLML6344TRPBF; SOT95P237X112-3N; MFR.Part # IRLML6344TRPBF-HXY; LCSC Part # C6285738
U1: AO3401A; SOT-23; MFR.Part # AO3401A; LCSC Part # C15127
U2: SPX3819M5-L-3-3/TR; SOT-23-5; MFR.Part # SPX3819M5-L-3-3/TR; LCSC Part # C9055
U5: CH340K; ESSOP-10_3.9x4.9mm_P1.00mm; MFR.Part # CH340K; LCSC Part # C18208922
U6: 2N27002DW; SOT-363_SC-70-6; MFR.Part # 2N27002DW; LCSC Part # C5190214
U7: MPU-6050; MPU6050; MFR.Part # MPU-6050; LCSC Part # C24112
U8: ESP32-S3-WROOM-1; MFR.Part # ESP32-S3-WROOM-1-N8; LCSC Part # C2913198

Connections:
+3V3: C3.1, C4.1, C7.1, C10.1, C11.1, C12.1, C13.1, J4.3, J11.1, J12.1, J13.1, R4.2, R14.2, R16.2, R17.2, R18.2, R19.2, R20.2, R21.2, U2.5 (OUT), U5.7 (VCC), U7.8 (VLOGIC), U7.13 (VDD), U8.2 (3V3)
+5V: D1.2 (A), IC1.4 (VCC), IC1.8 (CE), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), LED2.2 (A), LED3.2 (A), R3.1, U1.1 (G)
+BATT: C5.1, C15.1, C16.1, C17.1, C18.1, D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), IC1.5 (BAT), J2.1, J7.1, J8.1, J9.1, J10.1, R26.1, U1.3 (D)
/ADC_BAT: R26.2, R27.1, U8.38 (IO2)
/AUXSCL: J13.3, U7.7 (AUX_CL)
/AUXSDA: J13.4, U7.6 (AUX_DA)
/BUZ1: J6.5, J14.2, U8.31 (IO38)
/BUZ2: J6.6, J14.1, U8.32 (IO39)
/CLK: J6.3, J11.4, U8.29 (IO36)
/CS: J6.1, J11.6, U8.35 (IO42)
/D+: J1.A6 (D+), J1.B6 (D+), U5.1 (D+)
/D-: J1.A7 (D-), J1.B7 (D-), U5.2 (D-)
/DTR: U5.4 (DTR), U6.2, U6.4
/EN: C14.1, R18.1, SW3.2, U6.6, U8.3 (EN)
/IO0: R19.1, SW2.2, U6.3, U8.27 (IO0)
/IO1: J5.1, R28.1, R29.1, R30.1, U8.39 (IO1)
/IO13: J4.4, U8.21 (IO13)
/IO14: U8.22 (IO14)
/IO15: J3.1, U8.8 (IO15)
/IO16: J3.2, U8.9 (IO16)
/IO17: J3.3, U8.10 (IO17)
/IO18: J3.4, U8.11 (IO18)
/IO19: J3.5, U8.13 (IO19)
/IO20: J3.6, U8.14 (IO20)
/IO21: U8.23 (IO21)
/IO48: J5.4, U8.25 (IO48)
/LDO_H: R8.2, SW1.3
/LED_BLUE: R13.2, U8.7 (IO7)
/LED_GREEN: R11.2, U8.17 (IO9)
/LED_RED: R12.2, U8.12 (IO8)
/MISO: J6.4, J11.5, U8.30 (IO37)
/MOSI: J6.2, J11.3, U8.28 (IO35)
/MOT_1: R22.2, T1.1 (G), U8.5 (IO5)
/MOT_2: R23.2, T2.1 (G), U8.6 (IO6)
/MOT_3: R24.2, T3.1 (G), U8.15 (IO3)
/MOT_4: R25.2, T4.1 (G), U8.4 (IO4)
/MPU_INT: R17.1, U7.12 (INT), U8.20 (IO12)
/RTS: U5.6 (RTS), U6.1, U6.5
/RX: J5.3, R10.1, U8.36 (RXD0)
/SCL: J4.6, R16.1, U7.23 (SCL), U8.18 (IO10)
/SCL1: J5.5, J12.3, R21.1, U8.34 (IO41)
/SDA: J4.5, R14.1, U7.24 (SDA), U8.19 (IO11)
/SDA1: J5.6, J12.4, R20.1, U8.33 (IO40)
/TX: J5.2, R9.1, U8.37 (TXD0)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.1, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, IC1.1 (TEMP), IC1.3 (GND), IC1.9 (EP), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.2, J4.2, J11.2, J12.2, J13.2, LED1.1 (K), LED4.1 (K), LED5.1 (K), LED6.1 (K), R1.2, R2.2, R3.2, R5.2, R15.1, R22.1, R23.1, R24.1, R25.1, R27.2, SW1.1, SW1.4, SW2.1, SW3.1, T1.2 (S), T2.2 (S), T3.2 (S), T4.2 (S), U2.2 (GND), U5.3 (GND), U5.11 (EP), U7.1 (CLKIN), U7.11 (FSYNC), U7.18 (GND), U8.1 (GND), U8.40 (GND), U8.41 (GND)
LDO_EN: SW1.2, U2.3 (EN)
unnamed: C15.2, D2.2 (A), J7.2, T1.3 (D)
unnamed: C16.2, D3.2 (A), J8.2, T2.3 (D)
unnamed: C17.2, D4.2 (A), J9.2, T3.3 (D)
unnamed: C18.2, D5.2 (A), J10.2, T4.3 (D)
unnamed: IC1.2 (PROG), R5.1
unnamed: IC1.7 (~CHRG), R6.2
unnamed: IC1.6 (~STDBY), R7.2
unnamed: J1.A5 (CC1), R2.1
unnamed: J1.B5 (CC2), R1.1
unnamed: J11.7, R29.2
unnamed: J11.8, R30.2
unnamed: J12.5, R28.2
unnamed: LED1.2 (A), R4.1
unnamed: LED2.1 (K), R6.1
unnamed: LED3.1 (K), R7.1
unnamed: LED4.2 (A), R11.1
unnamed: LED5.2 (A), R12.1
unnamed: LED6.2 (A), R13.1
unnamed: C2.1, U2.4 (BP)
unnamed: R9.2, U5.9 (RXD)
unnamed: R10.2, U5.8 (TXD)
unnamed: C6.2, U5.10 (V3)
unnamed: R15.2, U7.9 (AD0)
unnamed: C9.1, U7.20 (CPOUT)
unnamed: C8.1, U7.10 (REGOUT)
VBUS: C1.1, D1.1 (K), J4.1, R8.1, U1.2 (S), U2.1 (IN)

Notes on the sheet:
Note: Charging Current (mA) = 1100(V) / Rprog (kΩ)
IMU
VL53L1X Module
Debug LEDs
Battery Charging
3.3V Regulator
Battery Voltage Measurement
Auto Reset Circuit
USB - UART / Programming Circuit
SoC
Mototr Drivers
MS5611 Module
Exapnsion Connector
Auxiliary Modules
On/Off Circuit
PMW3901 Module

Board: 2 copper layers, 100.0 x 100.0 mm, 87 parts (3 on the bottom side), 70 nets.

## Commit log

2025-06-07 MPU6050 ESP32
2025-06-07 output
2025-06-09 MPU6050 datasheet added.
2025-06-14 MPU6050 datasheets and pinout
2025-06-14 MPU6050 offset
2025-06-15 VP notes added
2025-08-10 Added datasheets for Rx, Tx and ESC
2025-08-10 Added notes
2026-01-07 removing irrelavant files
2026-01-18 Added stores list for components
2026-03-03 Added yukta2k26 PPT
2026-03-13 test push
2026-05-29 Dronachariya project files
2026-05-29 files for litewing
2026-05-29 Added files for ESP32-fly
2026-05-29 removed litewing
2026-05-29 readded litewing
2026-06-19 Removed ESP-Fly
2026-06-19 Litewing
2026-06-19 Updated BOM
